# Keil uVision project i2c_mcu_master_poll.uvprojx, settings and files
target i2c_mcu_master_poll_Release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: i2c_mcu_master_poll
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l110.s
    ../../../../mcu/common/: system_hc32l110.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c interrupts_hc32l110.c clk.c i2c.c gpio.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
