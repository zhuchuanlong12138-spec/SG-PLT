# Keil uVision project clk_switch.uvprojx, settings and files
target clk_switch_Release (5060960::V5.06 update 7 (build 960)::.\ARMCompiler_506)
  device: HC32L110C6PA HDSC
  pack: HDSC.HC32L110.1.0.2
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: clk_switch
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l110.s
    ../../../../mcu/common/: system_hc32l110.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c interrupts_hc32l110.c clk.c gpio.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.0.1
